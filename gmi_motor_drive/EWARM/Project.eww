<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\gmi_motor_drive_48pin.ewp</path>
  </project>
  <batchBuild />
</workspace>
