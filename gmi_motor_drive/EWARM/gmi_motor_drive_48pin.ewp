# IAR project gmi_motor_drive_48pin.ewp, settings and files
configuration gmi_motor_drive_48pin (ARM, debug)
  General.OGChipSelectEditMenu: STM32F301C8 ST STM32F301C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F301x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F3xx/Inc; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gmi_motor_drive_48pin.hex
  ILINK.IlinkOutputFile: gmi_motor_drive_48pin.out
  ILINK.IlinkIcfFile: stm32f301x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f301x8.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f30x_mc_it.c mc_parameters.c ui_task.c user_interface.c dac_ui.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_adc.c stm32f3xx_ll_dma.c stm32f3xx_ll_rcc.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_ll_dac.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c inrush_current_limiter.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F3xx/Src/: r3_1_f30x_pwm_curr_fdbk.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Src/: dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
